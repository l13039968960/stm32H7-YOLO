# Keil uVision project look_h743.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.2
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: look_h743 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: STM32H743xx,USE_HAL_DRIVER
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\User;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Drivers\BSP;..\..\Drivers\BSP\LCD;..\..\Drivers\BSP\SPI;..\..\Drivers\BSP\OV2640;..\..\X-CUBE-AI\App;..\..\Middlewares\ST\AI\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group User
    ../../User/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/SPI/: spi.c
    ../../Drivers/BSP/LCD/: lcd.c Dis_Picture.c Picture.c Dis_Picture.h FONT.c FONT.H lcd.h Picture.h
    ../../Drivers/BSP/OV2640/: OV_Frame.c OV_Frame.h ov2640.c ov2640.h ov2640cfg.h sccb.c sccb.h dcmi.c dcmi.h
    ../../Drivers/BSP/MPU/: mpu.c mpu.h
  group X-CUBE-AI
    ../../X-CUBE-AI/App/: network.c network_data.c yoloface.c network_generate_report.txt
    ../../Middlewares/ST/AI/Lib/: NetworkRuntime700_CM7_Keil.lib
